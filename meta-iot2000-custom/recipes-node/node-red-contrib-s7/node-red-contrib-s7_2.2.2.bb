SUMMARY = "A Node-RED node to interact with Siemens S7 PLCs"

LICENSE = "GPL-3.0 & MIT & LGPLv2.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e49f4652534af377a713df3d9dec60cb"

inherit npm-ng

NPM_LOCAL_INSTALL_DIR = "/home/root/.node-red"
