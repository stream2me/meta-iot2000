SUMMARY = "A Node-RED clock generator node."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${IOT2000_MIT_LICENSE};md5=838c366f69b72c5df05c96dff79b35f2"

inherit npm-ng

NPM_LOCAL_INSTALL_DIR = "/home/root/.node-red"
