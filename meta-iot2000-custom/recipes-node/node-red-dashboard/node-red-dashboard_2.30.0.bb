SUMMARY = "A set of dashboard nodes for Node-RED"

LICENSE = "BSD-2-Clause & BSD-3-Clause & Apache-2.0 & ISC & MIT"
LIC_FILES_CHKSUM = "file://license.js;md5=be107337d853cec1120159fddb9bff14"

inherit npm-ng

NPM_LOCAL_INSTALL_DIR = "/home/root/.node-red"
