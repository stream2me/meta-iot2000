require recipes-core/images/core-image-rt.bb
require iot2000-custom-image.inc
