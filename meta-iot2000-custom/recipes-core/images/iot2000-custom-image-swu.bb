require iot2000-custom-image.bb
require custom-image-swu.inc
